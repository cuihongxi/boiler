# Keil uVision project 主程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARD\KEYSCAN;.\HARD\TM1640;.\HARD;.\HARD\UART\STC8;.\HARD\delay;.\HARD\printf;.\HARD\MPU430-SPI;.\HARD\interface;.\HARD\TAST
  group Source Group 1
    ./: main.c
  group HARD
    ./HARD/KEYSCAN/: KEYSCAN.C key.c
    ./HARD/TM1640/: TM1640.C SMG.C
    ./HARD/: UHEAD.H eeprom.c myFlash.c CRC.C List4_Malloc.C
    ./HARD/UART/STC8/: uart.c
    ./HARD/delay/: delay.c
    ./HARD/printf/: printf.c
    ./HARD/TAST/: addProcessTask.c
    ./HARD/MPU430-SPI/: spi.c
    ./HARD/interface/: interface.c
